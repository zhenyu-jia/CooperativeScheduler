# Keil uVision project CooperativeScheduler.uvprojx, settings and files
target Debug (6140000::V6.14::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CooperativeScheduler +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F10X_HD,_DEBUG,USE_FULL_ASSERT
  c include: ..\User;..\User\App\inc;..\User\Bsp\inc;..\User\System\inc;..\Scheduler
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c main.h config.c config.h stm32f10x_it.c stm32f10x_it.h
  group App/inc
    ../User/App/inc/: app.h
  group App/src
    ../User/App/src/: app.c
  group Bsp/inc
    ../User/Bsp/inc/: led.h usart.h dma.h
  group Bsp/src
    ../User/Bsp/src/: led.c usart.c dma.c
  group Scheduler
    ../Scheduler/: scheduler.c scheduler.h
    ../User/System/src/: clkconfig.c
    ../User/System/inc/: clkconfig.h
  group System
    ../User/System/src/: log.c
    ../User/System/inc/: log.h
  group Doc
    ../Doc/: 工程说明.txt
target Release (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: CooperativeScheduler
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.4.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0
